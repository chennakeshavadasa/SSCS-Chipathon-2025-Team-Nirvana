v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 800 -320 800 -260 {lab=#net1}
N 910 -260 1020 -260 {lab=#net1}
N 1020 -320 1020 -260 {lab=#net1}
N 800 -490 800 -380 {lab=vout1_minus}
N 1020 -490 1020 -380 {lab=vout1_plus}
N 800 -670 800 -580 {lab=VDD}
N 1020 -670 1020 -580 {lab=VDD}
N 1060 -350 1140 -350 {lab=vin_minus}
N 700 -350 760 -350 {lab=vin_plus}
N 910 -490 930 -490 {lab=vcm}
N 990 -490 1020 -490 {lab=vout1_plus}
N 800 -490 830 -490 {lab=vout1_minus}
N 840 -580 980 -580 {lab=vctrl}
N 800 -670 1020 -670 {lab=VDD}
N 800 -260 910 -260 {lab=#net1}
N 800 -350 1020 -350 {lab=GND}
N 1450 -660 1450 -620 {lab=vcm_ref}
N 1450 -590 1450 -490 {lab=#net2}
N 1350 -730 1410 -730 {lab=vcm_ref}
N 1350 -660 1350 -590 {lab=vcm_ref}
N 1350 -590 1410 -590 {lab=vcm_ref}
N 1450 -460 1450 -380 {lab=GND}
N 1360 -460 1410 -460 {lab=VDD}
N 1450 -770 1450 -730 {lab=#net3}
N 1350 -660 1450 -660 {lab=vcm_ref}
N 1690 -600 1690 -560 {lab=vcm_ref}
N 1610 -530 1650 -530 {lab=vcm_ref}
N 1610 -600 1610 -530 {lab=vcm_ref}
N 1610 -660 1650 -660 {lab=vcm_ref}
N 1690 -740 1690 -690 {lab=#net4}
N 1600 -770 1650 -770 {lab=GND}
N 1690 -800 1690 -770 {lab=#net5}
N 1690 -660 1710 -660 {lab=#net5}
N 1710 -800 1710 -660 {lab=#net5}
N 1690 -800 1710 -800 {lab=#net5}
N 1690 -830 1690 -800 {lab=#net5}
N 1690 -530 1690 -380 {lab=GND}
N 1450 -660 1610 -660 {lab=vcm_ref}
N 1610 -600 1690 -600 {lab=vcm_ref}
N 1240 -170 1240 -80 {lab=GND}
N 1240 -260 1240 -230 {lab=vctrl}
N 910 -150 910 -80 {lab=GND}
N 580 -150 870 -150 {lab=#net6}
N 530 -150 530 -80 {lab=GND}
N 530 -470 530 -190 {lab=#net6}
N 910 -260 910 -240 {lab=#net1}
N 530 -190 530 -180 {lab=#net6}
N 580 -190 580 -150 {lab=#net6}
N 530 -190 580 -190 {lab=#net6}
N 430 -190 530 -190 {lab=#net6}
N 430 -190 430 -150 {lab=#net6}
N 390 -150 390 -80 {lab=GND}
N 310 -440 350 -440 {lab=VDZ_RP}
N 310 -440 310 -380 {lab=VDZ_RP}
N 310 -380 390 -380 {lab=VDZ_RP}
N 390 -380 390 -320 {lab=VDZ_RP}
N 390 -260 390 -180 {lab=#net7}
N 160 -160 160 -80 {lab=GND}
N 160 -200 160 -190 {lab=VDZ_RN}
N 200 -440 310 -440 {lab=VDZ_RP}
N 390 -670 530 -670 {lab=VDD}
N 160 -280 160 -200 {lab=VDZ_RN}
N 160 -410 160 -340 {lab=#net8}
N 530 -670 800 -670 {lab=VDD}
N 530 -670 530 -530 {lab=VDD}
N 390 -670 390 -440 {lab=VDD}
N 160 -670 160 -440 {lab=VDD}
N 1450 -970 1690 -970 {lab=VDD}
N 1690 -970 1690 -890 {lab=VDD}
N 1450 -970 1450 -830 {lab=VDD}
N 1450 -380 1690 -380 {lab=GND}
N 910 -490 910 -440 {lab=vcm}
N 110 -160 120 -160 {lab=VDZ_RN}
N 110 -200 160 -200 {lab=VDZ_RN}
N 110 -200 110 -160 {lab=VDZ_RN}
N 1020 -550 1020 -490 {lab=vout1_plus}
N 800 -550 800 -490 {lab=vout1_minus}
N 1350 -730 1350 -660 {lab=vcm_ref}
N 1450 -700 1450 -660 {lab=vcm_ref}
N 1610 -660 1610 -600 {lab=vcm_ref}
N 1690 -630 1690 -600 {lab=vcm_ref}
N 570 -150 580 -150 {lab=#net6}
N 160 -670 390 -670 {lab=VDD}
N 910 -80 1240 -80 {lab=GND}
N 530 -80 910 -80 {lab=GND}
N 390 -80 530 -80 {lab=GND}
N 160 -80 390 -80 {lab=GND}
N 890 -490 910 -490 {lab=vcm}
N 390 -410 390 -380 {lab=VDZ_RP}
N 880 -1320 880 -1280 {lab=GND}
N 880 -1410 880 -1380 {lab=vctrln}
N 1360 -1420 1360 -1350 {lab=Vout_stg2_rn}
N 1280 -1320 1320 -1320 {lab=vcm_ref}
N 1280 -1450 1280 -1320 {lab=vcm_ref}
N 1280 -1450 1310 -1450 {lab=vcm_ref}
N 1310 -1450 1320 -1450 {lab=vcm_ref}
N 1360 -1530 1360 -1480 {lab=#net9}
N 1360 -1290 1360 -1240 {lab=GND}
N 1270 -1560 1320 -1560 {lab=vctrlp}
N 1360 -1590 1360 -1560 {lab=#net10}
N 1360 -1450 1380 -1450 {lab=#net10}
N 1380 -1590 1380 -1450 {lab=#net10}
N 1360 -1590 1380 -1590 {lab=#net10}
N 1360 -1620 1360 -1590 {lab=#net10}
N 1500 -1600 1500 -1560 {lab=GND}
N 1500 -1690 1500 -1660 {lab=vctrlp}
N 1360 -1320 1360 -1290 {lab=GND}
N 740 -1580 740 -1500 {lab=Vout_stg2_rp}
N 740 -1640 740 -1610 {lab=#net11}
N 740 -1470 740 -1440 {lab=#net12}
N 640 -1610 700 -1610 {lab=vcm_ref}
N 640 -1610 640 -1470 {lab=vcm_ref}
N 640 -1470 700 -1470 {lab=vcm_ref}
N 740 -1440 740 -1370 {lab=#net12}
N 740 -1310 740 -1270 {lab=GND}
N 740 -1340 740 -1310 {lab=GND}
N 650 -1340 700 -1340 {lab=vctrln}
N 740 -1650 740 -1640 {lab=#net11}
N 740 -1270 740 -1240 {lab=GND}
N 880 -1280 880 -1240 {lab=GND}
N 1360 -1760 1360 -1680 {lab=VDD}
N 740 -1760 740 -1710 {lab=VDD}
N 740 -1790 740 -1760 {lab=VDD}
N 740 -1240 740 -1200 {lab=GND}
N 880 -1240 880 -1200 {lab=GND}
N 1360 -1240 1360 -1200 {lab=GND}
N 1360 -1790 1360 -1760 {lab=VDD}
N 1500 -1560 1500 -1200 {lab=GND}
N 2020 -1090 2020 -1010 {lab=vgp1}
N 2020 -1150 2020 -1120 {lab=#net13}
N 2020 -980 2020 -950 {lab=#net14}
N 1920 -1120 1980 -1120 {lab=vout1_plus}
N 1920 -1120 1920 -980 {lab=vout1_plus}
N 1920 -980 1980 -980 {lab=vout1_plus}
N 2020 -950 2020 -880 {lab=#net14}
N 2020 -820 2020 -780 {lab=GND}
N 2020 -850 2020 -820 {lab=GND}
N 1930 -850 1980 -850 {lab=vctrln}
N 2020 -1160 2020 -1150 {lab=#net13}
N 2020 -780 2020 -750 {lab=GND}
N 2020 -1270 2020 -1220 {lab=VDD}
N 1860 -1050 1920 -1050 {lab=vout1_plus}
N 1800 -1050 1860 -1050 {lab=vout1_plus}
N 2550 -930 2550 -860 {lab=vgn1}
N 2470 -830 2510 -830 {lab=vout1_plus}
N 2470 -960 2470 -830 {lab=vout1_plus}
N 2470 -960 2500 -960 {lab=vout1_plus}
N 2500 -960 2510 -960 {lab=vout1_plus}
N 2550 -1040 2550 -990 {lab=#net15}
N 2550 -800 2550 -750 {lab=GND}
N 2460 -1070 2510 -1070 {lab=vctrlp}
N 2550 -1100 2550 -1070 {lab=#net16}
N 2550 -960 2570 -960 {lab=#net16}
N 2570 -1100 2570 -960 {lab=#net16}
N 2550 -1100 2570 -1100 {lab=#net16}
N 2550 -1130 2550 -1100 {lab=#net16}
N 2550 -830 2550 -800 {lab=GND}
N 2550 -1270 2550 -1190 {lab=VDD}
N 2410 -900 2470 -900 {lab=vout1_plus}
N 2350 -900 2410 -900 {lab=vout1_plus}
N 2020 -1050 2150 -1050 {lab=vgp1}
N 2550 -890 2760 -890 {lab=vgn1}
N 2850 -730 3010 -730 {lab=vgn1}
N 3050 -730 3050 -700 {lab=GND}
N 3050 -700 3050 -610 {lab=GND}
N 740 -1790 1360 -1790 {lab=VDD}
N 740 -1200 1500 -1200 {lab=GND}
N 2850 -1060 3010 -1060 {lab=vgp1}
N 3050 -1030 3050 -760 {lab=Vout_m}
N 3050 -1250 3050 -1170 {lab=VDD}
N 3050 -1170 3050 -1090 {lab=VDD}
N 320 -1090 320 -1010 {lab=vgp2}
N 320 -1150 320 -1120 {lab=#net17}
N 320 -980 320 -950 {lab=#net18}
N 360 -1120 420 -1120 {lab=vout1_minus}
N 420 -1120 420 -980 {lab=vout1_minus}
N 360 -980 420 -980 {lab=vout1_minus}
N 320 -950 320 -880 {lab=#net18}
N 320 -820 320 -780 {lab=GND}
N 320 -850 320 -820 {lab=GND}
N 360 -850 410 -850 {lab=vctrln}
N 320 -1160 320 -1150 {lab=#net17}
N 320 -780 320 -750 {lab=GND}
N 320 -1270 320 -1220 {lab=VDD}
N 420 -1050 480 -1050 {lab=vout1_minus}
N 480 -1050 540 -1050 {lab=vout1_minus}
N -210 -930 -210 -860 {lab=vgn2}
N -170 -830 -130 -830 {lab=vout1_minus}
N -130 -960 -130 -830 {lab=vout1_minus}
N -160 -960 -130 -960 {lab=vout1_minus}
N -170 -960 -160 -960 {lab=vout1_minus}
N -210 -1040 -210 -990 {lab=#net19}
N -210 -800 -210 -750 {lab=GND}
N -170 -1070 -120 -1070 {lab=vctrlp}
N -210 -1100 -210 -1070 {lab=#net20}
N -230 -960 -210 -960 {lab=#net20}
N -230 -1100 -230 -960 {lab=#net20}
N -230 -1100 -210 -1100 {lab=#net20}
N -210 -1130 -210 -1100 {lab=#net20}
N -210 -830 -210 -800 {lab=GND}
N -210 -1270 -210 -1190 {lab=VDD}
N -130 -900 -70 -900 {lab=vout1_minus}
N -70 -900 -10 -900 {lab=vout1_minus}
N 190 -1050 320 -1050 {lab=vgp2}
N -420 -890 -210 -890 {lab=vgn2}
N -690 -730 -530 -730 {lab=vgn2}
N -730 -730 -730 -700 {lab=GND}
N -730 -700 -730 -610 {lab=GND}
N -690 -1060 -530 -1060 {lab=vgp2}
N -730 -1030 -730 -760 {lab=Vout_m}
N -730 -1250 -730 -1170 {lab=VDD}
N -730 -1170 -730 -1090 {lab=VDD}
N -730 -1090 -730 -1060 {lab=VDD}
N 3050 -1090 3050 -1060 {lab=VDD}
N -1040 -910 -730 -910 {lab=Vout_m}
N 3050 -890 3360 -890 {lab=Vout_m}
N -1040 -780 -1040 -720 {lab=GND}
N -1040 -910 -1040 -840 {lab=Vout_m}
N 3360 -760 3360 -700 {lab=GND}
N 3360 -890 3360 -820 {lab=Vout_m}
N 320 -1500 320 -1460 {lab=GND}
N 320 -1610 320 -1560 {lab=VDD}
C {symbols/nfet_03v3.sym} 780 -350 0 0 {name=M1
L=0.5u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1040 -350 0 1 {name=M2
L=0.5u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 820 -580 0 1 {name=M3
L=1u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1000 -580 0 0 {name=M4
L=1u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/res.sym} 860 -490 1 0 {name=R1
value=100k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 960 -490 1 0 {name=R2
value=100k
footprint=1206
device=resistor
m=1}
C {devices/vdd.sym} 910 -670 0 0 {name=l2 lab=VDD}
C {symbols/nfet_03v3.sym} 1430 -590 0 0 {name=M5
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1430 -730 0 0 {name=M6
L=0.28u
W=0.22u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1430 -460 0 0 {name=M7
L=0.28u
W=0.22u
nf=1
m=4
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/ngspice_probe.sym} 1450 -520 0 0 {name=r3}
C {devices/ammeter.sym} 1450 -800 0 0 {name=Vmeas1 savecurrent=true spice_ignore=0}
C {devices/vdd.sym} 1360 -460 0 0 {name=l15 lab=VDD}
C {symbols/pfet_03v3.sym} 1670 -660 0 0 {name=M11
L=0.28u
W=0.22u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1670 -530 0 0 {name=M12
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1670 -770 0 0 {name=M13
L=0.28u
W=0.22u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/ammeter.sym} 1690 -860 0 0 {name=Vmeas3 savecurrent=true spice_ignore=0}
C {devices/ngspice_probe.sym} 1690 -710 0 1 {name=r4}
C {devices/gnd.sym} 1600 -770 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} 1560 -660 3 1 {name=p1 sig_type=std_logic lab=vcm_ref}
C {devices/gnd.sym} 910 -350 0 0 {name=l7 lab=GND}
C {devices/bsource.sym} 1240 -200 0 1 {name=B2 VAR=V FUNC="3.3 / ( 1 + exp(-10000 * V(vcm,vcm_ref)))" }
C {devices/lab_pin.sym} 1240 -260 2 1 {name=p4 sig_type=std_logic lab=vctrl}
C {devices/lab_pin.sym} 910 -440 1 1 {name=p2 sig_type=std_logic lab=vcm}
C {devices/lab_pin.sym} 910 -580 1 0 {name=p3 sig_type=std_logic lab=vctrl}
C {devices/vsource.sym} 700 -320 0 0 {name=V2 value="dc 1.65 ac 1" savecurrent=false}
C {devices/gnd.sym} 700 -290 0 0 {name=l8 lab=GND}
C {devices/ngspice_probe.sym} 910 -260 0 0 {name=r7}
C {symbols/nfet_03v3.sym} 890 -150 0 0 {name=M8
L=2u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 550 -150 0 1 {name=M9
L=2u
W=4u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/isource.sym} 530 -500 0 0 {name=I0 value=10u}
C {devices/ngspice_probe.sym} 760 -150 0 0 {name=r8}
C {devices/ammeter.sym} 910 -210 0 0 {name=Vmeas2 savecurrent=true spice_ignore=0}
C {symbols/nfet_03v3.sym} 410 -150 0 1 {name=M10
L=2u
W=4u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 370 -440 0 0 {name=M14
L=0.5u
W=15.375u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_pin.sym} 270 -440 1 0 {name=p5 sig_type=std_logic lab=VDZ_RP}
C {devices/ammeter.sym} 390 -290 0 0 {name=Vmeas4 savecurrent=true spice_ignore=0}
C {symbols/nfet_03v3.sym} 140 -160 0 0 {name=M15
L=0.5u
W=5u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/ammeter.sym} 160 -310 0 0 {name=Vmeas savecurrent=true spice_ignore=0}
C {symbols/pfet_03v3.sym} 180 -440 0 1 {name=M16
L=0.5u
W=15.375u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/gnd.sym} 910 -80 0 0 {name=l1 lab=GND}
C {devices/vsource.sym} 1140 -320 0 0 {name=V3 value="dc 1.65 ac 1 180" savecurrent=false}
C {devices/gnd.sym} 1140 -290 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} 700 -350 1 0 {name=p6 sig_type=std_logic lab=vin_plus}
C {devices/lab_pin.sym} 1140 -350 1 0 {name=p7 sig_type=std_logic lab=vin_minus}
C {devices/lab_pin.sym} 1020 -490 2 0 {name=p8 sig_type=std_logic lab=vout1_plus}
C {devices/lab_pin.sym} 800 -490 2 1 {name=p9 sig_type=std_logic lab=vout1_minus}
C {devices/ngspice_get_value.sym} 620 -360 0 0 {name=r5 node=@m.xm1.m0[gm]
descr="gm1"}
C {devices/ngspice_get_value.sym} 620 -330 0 0 {name=r13 node=@m.xm1.m0[gds]
descr="gds1"}
C {devices/ngspice_get_value.sym} 620 -300 0 0 {name=r6 node=@m.xm1.m0[cgg]
descr="cgg1"}
C {devices/ngspice_get_value.sym} 620 -270 0 0 {name=r10 node=v(@m.xm1.m0[vth])
descr="vth1"}
C {devices/ngspice_get_value.sym} 1050 -310 0 0 {name=r11 node=@m.xm2.m0[gm]
descr="gm2"}
C {devices/ngspice_get_value.sym} 1050 -280 0 0 {name=r12 node=@m.xm2.m0[gds]
descr="gds2"}
C {devices/ngspice_get_value.sym} 1050 -250 0 0 {name=r14 node=@m.xm2.m0[cgg]
descr="cgg2"}
C {devices/ngspice_get_value.sym} 1050 -220 0 0 {name=r15 node=v(@m.xm2.m0[vth])
descr="vth2"}
C {devices/ngspice_get_value.sym} 620 -610 0 0 {name=r16 node=@m.xm3.m0[gm]
descr="gm3"}
C {devices/ngspice_get_value.sym} 620 -580 0 0 {name=r17 node=@m.xm3.m0[gds]
descr="gds3"}
C {devices/ngspice_get_value.sym} 620 -550 0 0 {name=r18 node=@m.xm3.m0[cgg]
descr="cgg3"}
C {devices/ngspice_get_value.sym} 620 -520 0 0 {name=r19 node=v(@m.xm3.m0[vth])
descr="vth3"}
C {devices/ngspice_get_value.sym} 1130 -600 0 0 {name=r20 node=@m.xm4.m0[gm]
descr="gm4"}
C {devices/ngspice_get_value.sym} 1130 -570 0 0 {name=r21 node=@m.xm4.m0[gds]
descr="gds4"}
C {devices/ngspice_get_value.sym} 1130 -540 0 0 {name=r22 node=@m.xm4.m0[cgg]
descr="cgg4"}
C {devices/ngspice_get_value.sym} 1130 -510 0 0 {name=r23 node=v(@m.xm4.m0[vth])
descr="vth4"}
C {devices/ngspice_get_value.sym} 620 -240 0 0 {name=r24 node=tcleval(@m.xm1.m0[gm]/@m.xm1.m0[gds])
descr="gm/gds1"}
C {devices/bsource.sym} 880 -1350 0 0 {name=B1 VAR=V FUNC="3.3 / ( 1 + exp(-10000 * V(Vout_stg2_rp,VDZ_RP)))" }
C {devices/lab_pin.sym} 880 -1410 2 0 {name=p11 sig_type=std_logic lab=vctrln}
C {devices/launcher.sym} 950 -1600 0 0 {name=h2
descr="load op & annotate" 
tclcommand="xschem raw_read $netlist_dir/Inv-Damp.raw; set show_hidden_texts 1; xschem annotate_op"}
C {symbols/pfet_03v3.sym} 1340 -1450 0 0 {name=M23
L=0.28u
W=0.22u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1340 -1320 0 0 {name=M24
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1340 -1560 0 0 {name=M25
L=0.28u
W=0.22u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_pin.sym} 1270 -1560 0 0 {name=p13 sig_type=std_logic lab=vctrlp}
C {devices/ammeter.sym} 1360 -1650 0 0 {name=Vmeas6 savecurrent=true spice_ignore=0}
C {devices/bsource.sym} 1500 -1630 0 0 {name=B3 VAR=V FUNC="3.3 / ( 1 + exp(-10000 * V(Vout_stg2_rn,VDZ_RN)))" }
C {devices/lab_pin.sym} 1500 -1690 2 0 {name=p14 sig_type=std_logic lab=vctrlp}
C {devices/lab_pin.sym} 1360 -1390 0 1 {name=p16 sig_type=std_logic lab=Vout_stg2_rn}
C {devices/ngspice_probe.sym} 1360 -1500 0 1 {name=r27}
C {symbols/nfet_03v3.sym} 720 -1470 0 0 {name=M30
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 720 -1610 0 0 {name=M31
L=0.28u
W=0.22u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 720 -1340 0 0 {name=M32
L=0.28u
W=0.22u
nf=1
m=4
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/ngspice_probe.sym} 740 -1400 0 0 {name=r29}
C {devices/ammeter.sym} 740 -1680 0 0 {name=Vmeas8 savecurrent=true spice_ignore=0}
C {devices/lab_pin.sym} 650 -1340 2 1 {name=p18 sig_type=std_logic lab=vctrln}
C {devices/lab_pin.sym} 740 -1540 0 1 {name=p20 sig_type=std_logic lab=Vout_stg2_rp}
C {devices/lab_pin.sym} 640 -1540 2 1 {name=p17 sig_type=std_logic lab=vcm_ref}
C {devices/lab_pin.sym} 1280 -1380 2 1 {name=p12 sig_type=std_logic lab=vcm_ref}
C {symbols/nfet_03v3.sym} 2000 -980 0 0 {name=M17
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2000 -1120 0 0 {name=M18
L=0.28u
W=0.22u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2000 -850 0 0 {name=M19
L=0.28u
W=0.22u
nf=1
m=4
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/ngspice_probe.sym} 2020 -910 0 0 {name=r26}
C {devices/ammeter.sym} 2020 -1190 0 0 {name=Vmeas5 savecurrent=true spice_ignore=0}
C {devices/lab_pin.sym} 1930 -850 2 1 {name=p19 sig_type=std_logic lab=vctrln}
C {devices/gnd.sym} 2020 -750 0 0 {name=l4 lab=GND}
C {devices/vdd.sym} 2020 -1270 0 0 {name=l5 lab=VDD}
C {symbols/pfet_03v3.sym} 2530 -960 0 0 {name=M27
L=0.28u
W=0.22u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2530 -830 0 0 {name=M28
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2530 -1070 0 0 {name=M29
L=0.28u
W=0.22u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_pin.sym} 2460 -1070 0 0 {name=p22 sig_type=std_logic lab=vctrlp}
C {devices/ammeter.sym} 2550 -1160 0 0 {name=Vmeas7 savecurrent=true spice_ignore=0}
C {devices/ngspice_probe.sym} 2550 -1010 0 1 {name=r28}
C {devices/vdd.sym} 2550 -1270 0 0 {name=l6 lab=VDD}
C {devices/gnd.sym} 2550 -750 0 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} 2150 -1050 3 1 {name=p24 sig_type=std_logic lab=vgp1}
C {devices/lab_pin.sym} 2760 -890 3 1 {name=p25 sig_type=std_logic lab=vgn1}
C {devices/lab_pin.sym} 1800 -1050 2 1 {name=p21 sig_type=std_logic lab=vout1_plus}
C {symbols/nfet_03v3.sym} 3030 -730 0 0 {name=M33
L=0.5u
W=5u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/lab_pin.sym} 2850 -730 2 1 {name=p26 sig_type=std_logic lab=vgn1}
C {devices/lab_pin.sym} 110 -200 0 0 {name=p27 sig_type=std_logic lab=VDZ_RN}
C {devices/vdd.sym} 1090 -1790 0 0 {name=l10 lab=VDD}
C {devices/gnd.sym} 1090 -1200 0 0 {name=l11 lab=GND}
C {symbols/pfet_03v3.sym} 3030 -1060 0 0 {name=M20
L=0.5u
W=15.375u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_pin.sym} 2850 -1060 2 1 {name=p10 sig_type=std_logic lab=vgp1}
C {devices/gnd.sym} 3050 -610 0 0 {name=l12 lab=GND}
C {devices/vdd.sym} 3050 -1250 0 0 {name=l13 lab=VDD}
C {devices/lab_pin.sym} 2350 -900 2 1 {name=p15 sig_type=std_logic lab=vout1_plus}
C {devices/vdd.sym} 1570 -970 0 0 {name=l14 lab=VDD}
C {devices/gnd.sym} 1580 -380 0 0 {name=l16 lab=GND}
C {symbols/nfet_03v3.sym} 340 -980 0 1 {name=M21
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 340 -1120 0 1 {name=M22
L=0.28u
W=0.22u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 340 -850 0 1 {name=M26
L=0.28u
W=0.22u
nf=1
m=4
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/ngspice_probe.sym} 320 -910 0 1 {name=r9}
C {devices/ammeter.sym} 320 -1190 0 1 {name=Vmeas9 savecurrent=true spice_ignore=0}
C {devices/lab_pin.sym} 410 -850 2 0 {name=p23 sig_type=std_logic lab=vctrln}
C {devices/gnd.sym} 320 -750 0 1 {name=l17 lab=GND}
C {devices/vdd.sym} 320 -1270 0 1 {name=l19 lab=VDD}
C {symbols/pfet_03v3.sym} -190 -960 0 1 {name=M34
L=0.28u
W=0.22u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} -190 -830 0 1 {name=M35
L=0.28u
W=0.22u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -190 -1070 0 1 {name=M36
L=0.28u
W=0.22u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_pin.sym} -120 -1070 0 1 {name=p28 sig_type=std_logic lab=vctrlp}
C {devices/ammeter.sym} -210 -1160 0 1 {name=Vmeas10 savecurrent=true spice_ignore=0}
C {devices/ngspice_probe.sym} -210 -1010 0 0 {name=r25}
C {devices/vdd.sym} -210 -1270 0 1 {name=l20 lab=VDD}
C {devices/gnd.sym} -210 -750 0 1 {name=l21 lab=GND}
C {devices/lab_pin.sym} 190 -1050 1 0 {name=p29 sig_type=std_logic lab=vgp2}
C {devices/lab_pin.sym} -420 -890 1 0 {name=p30 sig_type=std_logic lab=vgn2}
C {devices/lab_pin.sym} 540 -1050 2 0 {name=p31 sig_type=std_logic lab=vout1_minus}
C {devices/lab_pin.sym} -10 -900 2 0 {name=p32 sig_type=std_logic lab=vout1_minus}
C {symbols/nfet_03v3.sym} -710 -730 0 1 {name=M37
L=0.5u
W=5u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} -710 -1060 0 1 {name=M38
L=0.5u
W=15.375u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/gnd.sym} -730 -610 0 1 {name=l22 lab=GND}
C {devices/vdd.sym} -730 -1250 0 1 {name=l23 lab=VDD}
C {devices/lab_pin.sym} -530 -730 2 0 {name=p33 sig_type=std_logic lab=vgn2}
C {devices/lab_pin.sym} -530 -1060 2 0 {name=p34 sig_type=std_logic lab=vgp2}
C {devices/capa.sym} -1040 -810 0 0 {name=C1
m=1
value=250p
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} -1040 -720 0 1 {name=l24 lab=GND}
C {devices/capa.sym} 3360 -790 0 0 {name=C2
m=1
value=250p
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 3360 -700 0 1 {name=l25 lab=GND}
C {devices/lab_pin.sym} -1040 -910 2 1 {name=p35 sig_type=std_logic lab=Vout_m}
C {devices/lab_pin.sym} 3360 -890 2 0 {name=p36 sig_type=std_logic lab=Vout_p}
C {devices/vsource.sym} 320 -1530 0 0 {name=V1 value=3.3 savecurrent=false}
C {devices/gnd.sym} 320 -1460 0 0 {name=l26 lab=GND}
C {devices/vdd.sym} 320 -1610 0 0 {name=l27 lab=VDD}
C {devices/code_shown.sym} 0 -1980 0 0 {name=NGSPICE only_toplevel=true 
value="
.option wnflag=1
.option savecurrents
.temp 27
.control
save all
write Ramp_tb_try.raw
set appendwrite 
op
write Ramp_tb_try.raw
**dc V1 0 1.65 1m
tran 1m 10m 1m
**tran 100n 5u 100n
**ac dec 20 1 1e10
*plot vdb(vout_plus)
*plot vdb(vout_minus)
**let vout=v(vout_plus)-v(vout_minus)
**plot vdb(vout)
.endc
"}
C {devices/code.sym} 0 -1560 0 0 {name=SAVE_COMMANDS only_toplevel=false value="
.save @m.xm1.m0[gm]
.save @m.xm1.m0[id]
.save @m.xm1.m0[vth]
.save @m.xm1.m0[gds]
.save @m.xm1.m0[cgg]
.save @m.xm1.m0[cgs]
.save @m.xm1.m0[cgd]
.save @m.xm2.m0[gm]
.save @m.xm2.m0[id]
.save @m.xm2.m0[vth]
.save @m.xm2.m0[gds]
.save @m.xm2.m0[cgg]
.save @m.xm2.m0[cgs]
.save @m.xm2.m0[cgd]
.save @m.xm3.m0[gm]
.save @m.xm3.m0[id]
.save @m.xm3.m0[vth]
.save @m.xm3.m0[vds]
.save @m.xm3.m0[gds]
.save @m.xm3.m0[cgg]
.save @m.xm3.m0[cgs]
.save @m.xm3.m0[cgd]
.save @m.xm4.m0[gm]
.save @m.xm4.m0[id]
.save @m.xm4.m0[vth]
.save @m.xm4.m0[vds]
.save @m.xm4.m0[gds]
.save @m.xm4.m0[cgg]
.save @m.xm4.m0[cgs]
.save @m.xm4.m0[cgd]
"}
C {devices/launcher.sym} 90 -1390 0 0 {name=h1
descr="load op & annotate" 
tclcommand="xschem raw_read $netlist_dir/Inv-Damp.raw; set show_hidden_texts 1; xschem annotate_op"}
C {devices/code.sym} 150 -1560 0 0 {name=MODELS only_toplevel=true
format="tcleval( @value )"
value="
.lib /foss/pdks/volare/gf180mcu/versions/0fe599b2afb6708d281543108caf8310912f54af/gf180mcuD/libs.tech/ngspice/sm141064.ngspice typical
.include /foss/pdks/volare/gf180mcu/versions/0fe599b2afb6708d281543108caf8310912f54af/gf180mcuD/libs.tech/ngspice/design.ngspice 
.lib /foss/pdks/volare/gf180mcu/versions/0fe599b2afb6708d281543108caf8310912f54af/gf180mcuD/libs.tech/ngspice/sm141064.ngspice res_statistical

**.include $::180MCU_MODELS/design.ngspice
**.lib $::180MCU_MODELS/sm141064.ngspice typical
**.lib $::180MCU_MODELS/sm141064.ngspice res_typical
* .lib $::180MCU_MODELS/sm141064.ngspice res_statistical
*.include $::180MCU_MODELS/design.ngspice
*.lib $::180MCU_MODELS/sm141064.ngspice typical

"}
