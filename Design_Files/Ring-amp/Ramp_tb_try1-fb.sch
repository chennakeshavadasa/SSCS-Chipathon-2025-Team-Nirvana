v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
T {Nithin Purushothama} 1940 -2080 0 0 1 1 {}
T {Fully Differential Ring Amplifier} 1370 -2250 0 0 2 2 {}
N 1940 -430 1940 -370 {lab=#net1}
N 2050 -370 2160 -370 {lab=#net1}
N 2160 -430 2160 -370 {lab=#net1}
N 1940 -600 1940 -490 {lab=vout1_minus}
N 2160 -600 2160 -490 {lab=vout1_plus}
N 1940 -780 1940 -690 {lab=VDD}
N 2160 -780 2160 -690 {lab=VDD}
N 2200 -460 2280 -460 {lab=Vin_m}
N 1840 -460 1900 -460 {lab=Vin_p}
N 2050 -600 2070 -600 {lab=vcm}
N 2130 -600 2160 -600 {lab=vout1_plus}
N 1940 -600 1970 -600 {lab=vout1_minus}
N 1980 -690 2120 -690 {lab=vctrl}
N 1940 -780 2160 -780 {lab=VDD}
N 1940 -370 2050 -370 {lab=#net1}
N 1940 -460 2160 -460 {lab=GND}
N 2590 -770 2590 -730 {lab=vcm_ref}
N 2490 -840 2550 -840 {lab=vcm_ref}
N 2490 -770 2490 -700 {lab=vcm_ref}
N 2490 -700 2550 -700 {lab=vcm_ref}
N 2590 -570 2590 -490 {lab=GND}
N 2500 -570 2550 -570 {lab=VDD}
N 2590 -880 2590 -840 {lab=#net2}
N 2490 -770 2590 -770 {lab=vcm_ref}
N 2830 -710 2830 -670 {lab=vcm_ref}
N 2750 -640 2790 -640 {lab=vcm_ref}
N 2750 -710 2750 -640 {lab=vcm_ref}
N 2750 -770 2790 -770 {lab=vcm_ref}
N 2830 -850 2830 -800 {lab=#net3}
N 2740 -880 2790 -880 {lab=GND}
N 2830 -910 2830 -880 {lab=#net4}
N 2830 -770 2850 -770 {lab=#net4}
N 2850 -910 2850 -770 {lab=#net4}
N 2830 -910 2850 -910 {lab=#net4}
N 2830 -940 2830 -910 {lab=#net4}
N 2830 -640 2830 -490 {lab=GND}
N 2590 -770 2750 -770 {lab=vcm_ref}
N 2750 -710 2830 -710 {lab=vcm_ref}
N 2380 -280 2380 -190 {lab=GND}
N 2380 -370 2380 -340 {lab=vctrl}
N 2050 -260 2050 -190 {lab=GND}
N 1720 -260 2010 -260 {lab=#net5}
N 1670 -260 1670 -190 {lab=GND}
N 1670 -580 1670 -300 {lab=#net5}
N 2050 -370 2050 -350 {lab=#net1}
N 1670 -300 1670 -290 {lab=#net5}
N 1720 -300 1720 -260 {lab=#net5}
N 1670 -300 1720 -300 {lab=#net5}
N 1570 -300 1670 -300 {lab=#net5}
N 1570 -300 1570 -260 {lab=#net5}
N 1530 -260 1530 -190 {lab=GND}
N 1450 -550 1490 -550 {lab=VDZ_RP}
N 1450 -550 1450 -490 {lab=VDZ_RP}
N 1450 -490 1530 -490 {lab=VDZ_RP}
N 1530 -490 1530 -430 {lab=VDZ_RP}
N 1530 -370 1530 -290 {lab=#net6}
N 1300 -270 1300 -190 {lab=GND}
N 1300 -310 1300 -300 {lab=VDZ_RN}
N 1340 -550 1450 -550 {lab=VDZ_RP}
N 1530 -780 1670 -780 {lab=VDD}
N 1300 -390 1300 -310 {lab=VDZ_RN}
N 1300 -520 1300 -450 {lab=#net7}
N 1670 -780 1940 -780 {lab=VDD}
N 1670 -780 1670 -640 {lab=VDD}
N 1530 -780 1530 -550 {lab=VDD}
N 1300 -780 1300 -550 {lab=VDD}
N 2590 -1080 2830 -1080 {lab=VDD}
N 2830 -1080 2830 -1000 {lab=VDD}
N 2590 -1080 2590 -940 {lab=VDD}
N 2590 -490 2830 -490 {lab=GND}
N 2050 -600 2050 -550 {lab=vcm}
N 1250 -270 1260 -270 {lab=VDZ_RN}
N 1250 -310 1300 -310 {lab=VDZ_RN}
N 1250 -310 1250 -270 {lab=VDZ_RN}
N 2160 -660 2160 -600 {lab=vout1_plus}
N 1940 -660 1940 -600 {lab=vout1_minus}
N 2490 -840 2490 -770 {lab=vcm_ref}
N 2590 -810 2590 -770 {lab=vcm_ref}
N 2750 -770 2750 -710 {lab=vcm_ref}
N 2830 -740 2830 -710 {lab=vcm_ref}
N 1710 -260 1720 -260 {lab=#net5}
N 1300 -780 1530 -780 {lab=VDD}
N 2050 -190 2380 -190 {lab=GND}
N 1670 -190 2050 -190 {lab=GND}
N 1530 -190 1670 -190 {lab=GND}
N 1300 -190 1530 -190 {lab=GND}
N 2030 -600 2050 -600 {lab=vcm}
N 1530 -520 1530 -490 {lab=VDZ_RP}
N 2020 -1430 2020 -1390 {lab=GND}
N 2020 -1520 2020 -1490 {lab=vctrln}
N 2500 -1530 2500 -1460 {lab=Vout_stg2_rn}
N 2420 -1430 2460 -1430 {lab=vcm_ref}
N 2420 -1560 2420 -1430 {lab=vcm_ref}
N 2420 -1560 2450 -1560 {lab=vcm_ref}
N 2450 -1560 2460 -1560 {lab=vcm_ref}
N 2500 -1640 2500 -1590 {lab=#net8}
N 2500 -1400 2500 -1350 {lab=GND}
N 2410 -1670 2460 -1670 {lab=vctrlp}
N 2500 -1700 2500 -1670 {lab=#net9}
N 2500 -1560 2520 -1560 {lab=#net9}
N 2520 -1700 2520 -1560 {lab=#net9}
N 2500 -1700 2520 -1700 {lab=#net9}
N 2500 -1730 2500 -1700 {lab=#net9}
N 2640 -1710 2640 -1670 {lab=GND}
N 2640 -1800 2640 -1770 {lab=vctrlp}
N 2500 -1430 2500 -1400 {lab=GND}
N 1880 -1690 1880 -1610 {lab=Vout_stg2_rp}
N 1880 -1750 1880 -1720 {lab=#net10}
N 1880 -1580 1880 -1550 {lab=#net11}
N 1780 -1720 1840 -1720 {lab=vcm_ref}
N 1780 -1720 1780 -1580 {lab=vcm_ref}
N 1780 -1580 1840 -1580 {lab=vcm_ref}
N 1880 -1550 1880 -1480 {lab=#net11}
N 1880 -1420 1880 -1380 {lab=GND}
N 1880 -1450 1880 -1420 {lab=GND}
N 1790 -1450 1840 -1450 {lab=vctrln}
N 1880 -1760 1880 -1750 {lab=#net10}
N 1880 -1380 1880 -1350 {lab=GND}
N 2020 -1390 2020 -1350 {lab=GND}
N 2500 -1870 2500 -1790 {lab=VDD}
N 1880 -1870 1880 -1820 {lab=VDD}
N 1880 -1900 1880 -1870 {lab=VDD}
N 1880 -1350 1880 -1310 {lab=GND}
N 2020 -1350 2020 -1310 {lab=GND}
N 2500 -1350 2500 -1310 {lab=GND}
N 2500 -1900 2500 -1870 {lab=VDD}
N 2640 -1670 2640 -1310 {lab=GND}
N 3160 -1200 3160 -1120 {lab=vgp1}
N 3160 -1260 3160 -1230 {lab=#net12}
N 3060 -1230 3120 -1230 {lab=vout1_plus}
N 3060 -1230 3060 -1090 {lab=vout1_plus}
N 3060 -1090 3120 -1090 {lab=vout1_plus}
N 3160 -1060 3160 -990 {lab=#net13}
N 3160 -930 3160 -890 {lab=GND}
N 3160 -960 3160 -930 {lab=GND}
N 3070 -960 3120 -960 {lab=vctrln}
N 3160 -1270 3160 -1260 {lab=#net12}
N 3160 -890 3160 -860 {lab=GND}
N 3160 -1380 3160 -1330 {lab=VDD}
N 3000 -1160 3060 -1160 {lab=vout1_plus}
N 2940 -1160 3000 -1160 {lab=vout1_plus}
N 3690 -1040 3690 -970 {lab=vgn1}
N 3610 -940 3650 -940 {lab=vout1_plus}
N 3610 -1070 3610 -940 {lab=vout1_plus}
N 3610 -1070 3640 -1070 {lab=vout1_plus}
N 3640 -1070 3650 -1070 {lab=vout1_plus}
N 3690 -1150 3690 -1100 {lab=#net14}
N 3690 -910 3690 -860 {lab=GND}
N 3600 -1180 3650 -1180 {lab=vctrlp}
N 3690 -1210 3690 -1180 {lab=#net15}
N 3690 -1070 3710 -1070 {lab=#net15}
N 3710 -1210 3710 -1070 {lab=#net15}
N 3690 -1210 3710 -1210 {lab=#net15}
N 3690 -1240 3690 -1210 {lab=#net15}
N 3690 -940 3690 -910 {lab=GND}
N 3690 -1380 3690 -1300 {lab=VDD}
N 3550 -1010 3610 -1010 {lab=vout1_plus}
N 3490 -1010 3550 -1010 {lab=vout1_plus}
N 3160 -1160 3290 -1160 {lab=vgp1}
N 3690 -1000 3900 -1000 {lab=vgn1}
N 3990 -840 4150 -840 {lab=vgn1}
N 4190 -840 4190 -810 {lab=GND}
N 4190 -810 4190 -720 {lab=GND}
N 1880 -1900 2500 -1900 {lab=VDD}
N 1880 -1310 2640 -1310 {lab=GND}
N 3990 -1170 4150 -1170 {lab=vgp1}
N 4190 -1140 4190 -870 {lab=Vout_p}
N 4190 -1360 4190 -1280 {lab=VDD}
N 4190 -1280 4190 -1200 {lab=VDD}
N 1460 -1200 1460 -1120 {lab=vgp2}
N 1460 -1260 1460 -1230 {lab=#net16}
N 1500 -1230 1560 -1230 {lab=vout1_minus}
N 1560 -1230 1560 -1090 {lab=vout1_minus}
N 1500 -1090 1560 -1090 {lab=vout1_minus}
N 1460 -1060 1460 -990 {lab=#net17}
N 1460 -930 1460 -890 {lab=GND}
N 1460 -960 1460 -930 {lab=GND}
N 1500 -960 1550 -960 {lab=vctrln}
N 1460 -1270 1460 -1260 {lab=#net16}
N 1460 -890 1460 -860 {lab=GND}
N 1460 -1380 1460 -1330 {lab=VDD}
N 1560 -1160 1620 -1160 {lab=vout1_minus}
N 1620 -1160 1680 -1160 {lab=vout1_minus}
N 930 -1040 930 -970 {lab=vgn2}
N 970 -940 1010 -940 {lab=vout1_minus}
N 1010 -1070 1010 -940 {lab=vout1_minus}
N 980 -1070 1010 -1070 {lab=vout1_minus}
N 970 -1070 980 -1070 {lab=vout1_minus}
N 930 -1150 930 -1100 {lab=#net18}
N 930 -910 930 -860 {lab=GND}
N 970 -1180 1020 -1180 {lab=vctrlp}
N 930 -1210 930 -1180 {lab=#net19}
N 910 -1070 930 -1070 {lab=#net19}
N 910 -1210 910 -1070 {lab=#net19}
N 910 -1210 930 -1210 {lab=#net19}
N 930 -1240 930 -1210 {lab=#net19}
N 930 -940 930 -910 {lab=GND}
N 930 -1380 930 -1300 {lab=VDD}
N 1010 -1010 1070 -1010 {lab=vout1_minus}
N 1070 -1010 1130 -1010 {lab=vout1_minus}
N 1330 -1160 1460 -1160 {lab=vgp2}
N 720 -1000 930 -1000 {lab=vgn2}
N 450 -840 610 -840 {lab=vgn2}
N 410 -840 410 -810 {lab=GND}
N 410 -810 410 -720 {lab=GND}
N 450 -1170 610 -1170 {lab=vgp2}
N 410 -1140 410 -870 {lab=Vout_m}
N 410 -1360 410 -1280 {lab=VDD}
N 410 -1280 410 -1200 {lab=VDD}
N 410 -1200 410 -1170 {lab=VDD}
N 4190 -1200 4190 -1170 {lab=VDD}
N 100 -1020 410 -1020 {lab=Vout_m}
N 4190 -1000 4500 -1000 {lab=Vout_p}
N 100 -890 100 -830 {lab=GND}
N 100 -1020 100 -950 {lab=Vout_m}
N 4500 -870 4500 -810 {lab=GND}
N 4500 -1000 4500 -930 {lab=Vout_p}
N 3160 -930 3180 -930 {lab=GND}
N 2590 -630 2590 -600 {lab=#net20}
N 2590 -670 2590 -630 {lab=#net20}
N 2590 -700 2610 -700 {lab=GND}
N 2610 -700 2610 -570 {lab=GND}
N 2590 -570 2610 -570 {lab=GND}
N 1440 -1090 1460 -1090 {lab=GND}
N 1440 -1090 1440 -930 {lab=GND}
N 1440 -930 1460 -930 {lab=GND}
N 3160 -1090 3180 -1090 {lab=GND}
N 3180 -1090 3180 -930 {lab=GND}
N 540 -1760 780 -1760 {lab=VDD}
N 4500 -1000 4600 -1000 {lab=Vout_p}
N 0 -1020 100 -1020 {lab=Vout_p}
C {symbols/nfet_03v3.sym} 1920 -460 0 0 {name=M1
L=0.5u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2180 -460 0 1 {name=M2
L=0.5u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1960 -690 0 1 {name=M3
L=1u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2140 -690 0 0 {name=M4
L=1u
W=1u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/res.sym} 2000 -600 1 0 {name=R1
value=50k
footprint=1206
device=resistor
m=1}
C {devices/res.sym} 2100 -600 1 0 {name=R2
value=50k
footprint=1206
device=resistor
m=1}
C {devices/vdd.sym} 2050 -780 0 0 {name=l2 lab=VDD}
C {devices/ngspice_probe.sym} 2590 -630 0 0 {name=r3}
C {devices/ammeter.sym} 2590 -910 0 0 {name=Vmeas1 savecurrent=true spice_ignore=0}
C {devices/vdd.sym} 2500 -570 0 0 {name=l15 lab=VDD}
C {devices/ammeter.sym} 2830 -970 0 0 {name=Vmeas3 savecurrent=true spice_ignore=0}
C {devices/ngspice_probe.sym} 2830 -820 0 1 {name=r4}
C {devices/gnd.sym} 2740 -880 0 0 {name=l18 lab=GND}
C {devices/lab_pin.sym} 2700 -770 3 1 {name=p1 sig_type=std_logic lab=vcm_ref}
C {devices/gnd.sym} 2050 -460 0 0 {name=l7 lab=GND}
C {devices/bsource.sym} 2380 -310 0 1 {name=B2 VAR=V FUNC="3.3 / ( 1 + exp(-10000 * V(vcm,vcm_ref)))" }
C {devices/lab_pin.sym} 2380 -370 2 1 {name=p4 sig_type=std_logic lab=vctrl}
C {devices/lab_pin.sym} 2050 -550 1 1 {name=p2 sig_type=std_logic lab=vcm}
C {devices/lab_pin.sym} 2050 -690 1 0 {name=p3 sig_type=std_logic lab=vctrl}
C {devices/ngspice_probe.sym} 2050 -370 0 0 {name=r7}
C {symbols/nfet_03v3.sym} 2030 -260 0 0 {name=M8
L=2u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1690 -260 0 1 {name=M9
L=2u
W=4u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/isource.sym} 1670 -610 0 0 {name=I0 value=10u}
C {devices/ngspice_probe.sym} 1900 -260 0 0 {name=r8}
C {devices/ammeter.sym} 2050 -320 0 0 {name=Vmeas2 savecurrent=true spice_ignore=0}
C {symbols/nfet_03v3.sym} 1550 -260 0 1 {name=M10
L=2u
W=4u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1510 -550 0 0 {name=M14
L=0.5u
W=15.375u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_pin.sym} 1410 -550 1 0 {name=p5 sig_type=std_logic lab=VDZ_RP}
C {devices/ammeter.sym} 1530 -400 0 0 {name=Vmeas4 savecurrent=true spice_ignore=0}
C {symbols/nfet_03v3.sym} 1280 -270 0 0 {name=M15
L=0.5u
W=5u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/ammeter.sym} 1300 -420 0 0 {name=Vmeas savecurrent=true spice_ignore=0}
C {symbols/pfet_03v3.sym} 1320 -550 0 1 {name=M16
L=0.5u
W=15.375u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/gnd.sym} 2050 -190 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} 2160 -600 2 0 {name=p8 sig_type=std_logic lab=vout1_plus}
C {devices/lab_pin.sym} 1940 -600 2 1 {name=p9 sig_type=std_logic lab=vout1_minus}
C {devices/ngspice_get_value.sym} 1720 -470 0 0 {name=r5 node=@m.xm1.m0[gm]
descr="gm1"}
C {devices/ngspice_get_value.sym} 1720 -440 0 0 {name=r13 node=@m.xm1.m0[gds]
descr="gds1"}
C {devices/ngspice_get_value.sym} 1720 -410 0 0 {name=r6 node=@m.xm1.m0[cgg]
descr="cgg1"}
C {devices/ngspice_get_value.sym} 1720 -380 0 0 {name=r10 node=v(@m.xm1.m0[vth])
descr="vth1"}
C {devices/ngspice_get_value.sym} 2190 -420 0 0 {name=r11 node=@m.xm2.m0[gm]
descr="gm2"}
C {devices/ngspice_get_value.sym} 2190 -390 0 0 {name=r12 node=@m.xm2.m0[gds]
descr="gds2"}
C {devices/ngspice_get_value.sym} 2190 -360 0 0 {name=r14 node=@m.xm2.m0[cgg]
descr="cgg2"}
C {devices/ngspice_get_value.sym} 2190 -330 0 0 {name=r15 node=v(@m.xm2.m0[vth])
descr="vth2"}
C {devices/ngspice_get_value.sym} 1760 -720 0 0 {name=r16 node=@m.xm3.m0[gm]
descr="gm3"}
C {devices/ngspice_get_value.sym} 1760 -690 0 0 {name=r17 node=@m.xm3.m0[gds]
descr="gds3"}
C {devices/ngspice_get_value.sym} 1760 -660 0 0 {name=r18 node=@m.xm3.m0[cgg]
descr="cgg3"}
C {devices/ngspice_get_value.sym} 1760 -630 0 0 {name=r19 node=v(@m.xm3.m0[vth])
descr="vth3"}
C {devices/ngspice_get_value.sym} 2270 -710 0 0 {name=r20 node=@m.xm4.m0[gm]
descr="gm4"}
C {devices/ngspice_get_value.sym} 2270 -680 0 0 {name=r21 node=@m.xm4.m0[gds]
descr="gds4"}
C {devices/ngspice_get_value.sym} 2270 -650 0 0 {name=r22 node=@m.xm4.m0[cgg]
descr="cgg4"}
C {devices/ngspice_get_value.sym} 2270 -620 0 0 {name=r23 node=v(@m.xm4.m0[vth])
descr="vth4"}
C {devices/ngspice_get_value.sym} 1720 -350 0 0 {name=r24 node=tcleval(@m.xm1.m0[gm]/@m.xm1.m0[gds])
descr="gm/gds1"}
C {devices/bsource.sym} 2020 -1460 0 0 {name=B1 VAR=V FUNC="3.3 / ( 1 + exp(-10000 * V(Vout_stg2_rp,VDZ_RP)))" }
C {devices/lab_pin.sym} 2020 -1520 2 0 {name=p11 sig_type=std_logic lab=vctrln}
C {devices/launcher.sym} 2090 -1710 0 0 {name=h2
descr="load op & annotate" 
tclcommand="xschem raw_read $netlist_dir/Inv-Damp.raw; set show_hidden_texts 1; xschem annotate_op"}
C {devices/lab_pin.sym} 2410 -1670 0 0 {name=p13 sig_type=std_logic lab=vctrlp}
C {devices/ammeter.sym} 2500 -1760 0 0 {name=Vmeas6 savecurrent=true spice_ignore=0}
C {devices/bsource.sym} 2640 -1740 0 0 {name=B3 VAR=V FUNC="3.3 / ( 1 + exp(-10000 * V(Vout_stg2_rn,VDZ_RN)))" }
C {devices/lab_pin.sym} 2640 -1800 2 0 {name=p14 sig_type=std_logic lab=vctrlp}
C {devices/lab_pin.sym} 2500 -1500 0 1 {name=p16 sig_type=std_logic lab=Vout_stg2_rn}
C {devices/ngspice_probe.sym} 2500 -1610 0 1 {name=r27}
C {devices/ngspice_probe.sym} 1880 -1510 0 0 {name=r29}
C {devices/ammeter.sym} 1880 -1790 0 0 {name=Vmeas8 savecurrent=true spice_ignore=0}
C {devices/lab_pin.sym} 1790 -1450 2 1 {name=p18 sig_type=std_logic lab=vctrln}
C {devices/lab_pin.sym} 1880 -1650 0 1 {name=p20 sig_type=std_logic lab=Vout_stg2_rp}
C {devices/lab_pin.sym} 1780 -1650 2 1 {name=p17 sig_type=std_logic lab=vcm_ref}
C {devices/lab_pin.sym} 2420 -1490 2 1 {name=p12 sig_type=std_logic lab=vcm_ref}
C {devices/ngspice_probe.sym} 3160 -1020 0 0 {name=r26}
C {devices/ammeter.sym} 3160 -1300 0 0 {name=Vmeas5 savecurrent=true spice_ignore=0}
C {devices/lab_pin.sym} 3070 -960 2 1 {name=p19 sig_type=std_logic lab=vctrln}
C {devices/gnd.sym} 3160 -860 0 0 {name=l4 lab=GND}
C {devices/vdd.sym} 3160 -1380 0 0 {name=l5 lab=VDD}
C {devices/lab_pin.sym} 3600 -1180 0 0 {name=p22 sig_type=std_logic lab=vctrlp}
C {devices/ammeter.sym} 3690 -1270 0 0 {name=Vmeas7 savecurrent=true spice_ignore=0}
C {devices/ngspice_probe.sym} 3690 -1120 0 1 {name=r28}
C {devices/vdd.sym} 3690 -1380 0 0 {name=l6 lab=VDD}
C {devices/gnd.sym} 3690 -860 0 0 {name=l9 lab=GND}
C {devices/lab_pin.sym} 3290 -1160 3 1 {name=p24 sig_type=std_logic lab=vgp1}
C {devices/lab_pin.sym} 3900 -1000 3 1 {name=p25 sig_type=std_logic lab=vgn1}
C {devices/lab_pin.sym} 2940 -1160 2 1 {name=p21 sig_type=std_logic lab=vout1_plus}
C {symbols/nfet_03v3.sym} 4170 -840 0 0 {name=M33
L=0.5u
W=5u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/lab_pin.sym} 3990 -840 2 1 {name=p26 sig_type=std_logic lab=vgn1}
C {devices/lab_pin.sym} 1250 -310 0 0 {name=p27 sig_type=std_logic lab=VDZ_RN}
C {devices/vdd.sym} 2230 -1900 0 0 {name=l10 lab=VDD}
C {devices/gnd.sym} 2230 -1310 0 0 {name=l11 lab=GND}
C {symbols/pfet_03v3.sym} 4170 -1170 0 0 {name=M20
L=0.5u
W=15.375u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_pin.sym} 3990 -1170 2 1 {name=p10 sig_type=std_logic lab=vgp1}
C {devices/gnd.sym} 4190 -720 0 0 {name=l12 lab=GND}
C {devices/vdd.sym} 4190 -1360 0 0 {name=l13 lab=VDD}
C {devices/lab_pin.sym} 3490 -1010 2 1 {name=p15 sig_type=std_logic lab=vout1_plus}
C {devices/vdd.sym} 2710 -1080 0 0 {name=l14 lab=VDD}
C {devices/gnd.sym} 2720 -490 0 0 {name=l16 lab=GND}
C {devices/ngspice_probe.sym} 1460 -1020 0 1 {name=r9}
C {devices/ammeter.sym} 1460 -1300 0 1 {name=Vmeas9 savecurrent=true spice_ignore=0}
C {devices/lab_pin.sym} 1550 -960 2 0 {name=p23 sig_type=std_logic lab=vctrln}
C {devices/gnd.sym} 1460 -860 0 1 {name=l17 lab=GND}
C {devices/vdd.sym} 1460 -1380 0 1 {name=l19 lab=VDD}
C {devices/lab_pin.sym} 1020 -1180 0 1 {name=p28 sig_type=std_logic lab=vctrlp}
C {devices/ammeter.sym} 930 -1270 0 1 {name=Vmeas10 savecurrent=true spice_ignore=0}
C {devices/ngspice_probe.sym} 930 -1120 0 0 {name=r25}
C {devices/vdd.sym} 930 -1380 0 1 {name=l20 lab=VDD}
C {devices/gnd.sym} 930 -860 0 1 {name=l21 lab=GND}
C {devices/lab_pin.sym} 1330 -1160 1 0 {name=p29 sig_type=std_logic lab=vgp2}
C {devices/lab_pin.sym} 720 -1000 1 0 {name=p30 sig_type=std_logic lab=vgn2}
C {devices/lab_pin.sym} 1680 -1160 2 0 {name=p31 sig_type=std_logic lab=vout1_minus}
C {devices/lab_pin.sym} 1130 -1010 2 0 {name=p32 sig_type=std_logic lab=vout1_minus}
C {symbols/nfet_03v3.sym} 430 -840 0 1 {name=M37
L=0.5u
W=5u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 430 -1170 0 1 {name=M38
L=0.5u
W=15.375u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/gnd.sym} 410 -720 0 1 {name=l22 lab=GND}
C {devices/vdd.sym} 410 -1360 0 1 {name=l23 lab=VDD}
C {devices/lab_pin.sym} 610 -840 2 0 {name=p33 sig_type=std_logic lab=vgn2}
C {devices/lab_pin.sym} 610 -1170 2 0 {name=p34 sig_type=std_logic lab=vgp2}
C {devices/capa.sym} 100 -920 0 0 {name=C1
m=1
value=250p
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 100 -830 0 1 {name=l24 lab=GND}
C {devices/capa.sym} 4500 -900 0 0 {name=C2
m=1
value=250p
footprint=1206
device="ceramic capacitor"}
C {devices/gnd.sym} 4500 -810 0 1 {name=l25 lab=GND}
C {devices/ngspice_get_value.sym} 4330 -1230 0 0 {name=r30 node=@m.xm20.m0[gm]
descr="gm20"}
C {devices/ngspice_get_value.sym} 4330 -1200 0 0 {name=r31 node=@m.xm20.m0[gds]
descr="gds20"}
C {devices/ngspice_get_value.sym} 4330 -1170 0 0 {name=r32 node=@m.xm20.m0[cgg]
descr="cgg20"}
C {devices/ngspice_get_value.sym} 4330 -1140 0 0 {name=r33 node=v(@m.xm20.m0[vth])
descr="vth20"}
C {devices/ngspice_get_value.sym} 4330 -920 0 0 {name=r34 node=@m.xm33.m0[gm]
descr="gm33"}
C {devices/ngspice_get_value.sym} 4330 -890 0 0 {name=r35 node=@m.xm33.m0[gds]
descr="gds33"}
C {devices/ngspice_get_value.sym} 4330 -860 0 0 {name=r36 node=@m.xm33.m0[cgg]
descr="cgg33"}
C {devices/ngspice_get_value.sym} 4330 -830 0 0 {name=r37 node=v(@m.xm33.m0[vth])
descr="vth33"}
C {symbols/pfet_03v3.sym} 1860 -1720 0 0 {name=M30
L=0.5u
W=0.5u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1860 -1580 0 0 {name=M31
L=0.5u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1860 -1450 0 0 {name=M32
L=0.28u
W=0.22u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2480 -1670 0 0 {name=M23
L=0.28u
W=0.22u
nf=1
m=20
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2480 -1560 0 0 {name=M24
L=0.5u
W=0.5u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2480 -1430 0 0 {name=M25
L=0.5u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1480 -1230 0 1 {name=M21
L=0.5u
W=0.5u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1480 -1090 0 1 {name=M22
L=0.5u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1480 -960 0 1 {name=M26
L=0.28u
W=0.22u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 950 -940 0 1 {name=M34
L=0.5u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 950 -1070 0 1 {name=M35
L=0.5u
W=0.5u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 950 -1180 0 1 {name=M36
L=0.28u
W=0.22u
nf=1
m=20
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2570 -840 0 0 {name=M5
L=0.5u
W=0.5u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2570 -700 0 0 {name=M6
L=0.5u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2570 -570 0 0 {name=M7
L=0.28u
W=0.22u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2810 -880 0 0 {name=M11
L=0.28u
W=0.22u
nf=1
m=20
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2810 -770 0 0 {name=M12
L=0.5u
W=0.5u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2810 -640 0 0 {name=M13
L=0.5u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3140 -1230 0 0 {name=M17
L=0.5u
W=0.5u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3140 -1090 0 0 {name=M18
L=0.5u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3140 -960 0 0 {name=M19
L=0.28u
W=0.22u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3670 -1180 0 0 {name=M27
L=0.28u
W=0.22u
nf=1
m=20
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 3670 -1070 0 0 {name=M28
L=0.5u
W=0.5u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 3670 -940 0 0 {name=M29
L=0.5u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/iopin.sym} 1840 -460 0 1 {name=p37 lab=Vin_p}
C {devices/iopin.sym} 2280 -460 0 0 {name=p6 lab=Vin_m}
C {devices/iopin.sym} 540 -1760 0 1 {name=p7 lab=VDD}
C {devices/vdd.sym} 780 -1760 0 0 {name=l3 lab=VDD}
C {devices/iopin.sym} 4600 -1000 0 0 {name=p38 lab=Vout_p}
C {devices/iopin.sym} 0 -1020 0 1 {name=p36 lab=Vout_m}
