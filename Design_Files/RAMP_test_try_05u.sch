v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 410 -240 410 -180 {lab=#net1}
N 520 -180 630 -180 {lab=#net1}
N 630 -240 630 -180 {lab=#net1}
N 410 -410 410 -300 {lab=vout_minus}
N 630 -410 630 -300 {lab=vout_plus}
N 410 -590 410 -500 {lab=VDD}
N 630 -590 630 -500 {lab=VDD}
N 670 -270 750 -270 {lab=vin_minus}
N 310 -270 370 -270 {lab=vin_plus}
N 450 -500 590 -500 {lab=vctrl}
N 410 -590 630 -590 {lab=VDD}
N 410 -180 520 -180 {lab=#net1}
N 410 -270 630 -270 {lab=GND}
N 520 -70 520 0 {lab=GND}
N 520 -180 520 -160 {lab=#net1}
N 630 -470 630 -410 {lab=vout_plus}
N 410 -470 410 -410 {lab=vout_minus}
N 130 -70 130 0 {lab=GND}
N 130 -390 130 -110 {lab=vbias}
N 130 -110 130 -100 {lab=vbias}
N 180 -110 180 -70 {lab=vbias}
N 130 -110 180 -110 {lab=vbias}
N 130 -590 130 -450 {lab=VDD}
N 170 -70 180 -70 {lab=vbias}
N 180 -70 480 -70 {lab=vbias}
N 130 0 520 -0 {lab=GND}
N 130 -590 410 -590 {lab=VDD}
N 0 -310 0 -270 {lab=GND}
N 0 -420 0 -370 {lab=VDD}
N 1000 -280 1000 -240 {lab=vcm_ref}
N 900 -350 960 -350 {lab=vcm_ref}
N 900 -280 900 -210 {lab=vcm_ref}
N 900 -210 960 -210 {lab=vcm_ref}
N 1000 -80 1000 0 {lab=GND}
N 910 -80 960 -80 {lab=VDD}
N 1000 -390 1000 -350 {lab=#net2}
N 900 -280 1000 -280 {lab=vcm_ref}
N 1240 -220 1240 -180 {lab=vcm_ref}
N 1160 -150 1200 -150 {lab=vcm_ref}
N 1160 -220 1160 -150 {lab=vcm_ref}
N 1160 -280 1200 -280 {lab=vcm_ref}
N 1240 -360 1240 -310 {lab=#net3}
N 1150 -390 1200 -390 {lab=GND}
N 1240 -420 1240 -390 {lab=#net4}
N 1240 -280 1260 -280 {lab=#net4}
N 1260 -420 1260 -280 {lab=#net4}
N 1240 -420 1260 -420 {lab=#net4}
N 1240 -450 1240 -420 {lab=#net4}
N 1240 -150 1240 0 {lab=GND}
N 1000 -280 1160 -280 {lab=vcm_ref}
N 1160 -220 1240 -220 {lab=vcm_ref}
N 1000 -520 1240 -520 {lab=VDD}
N 1000 0 1240 0 {lab=GND}
N 900 -350 900 -280 {lab=vcm_ref}
N 1000 -320 1000 -280 {lab=vcm_ref}
N 1160 -280 1160 -220 {lab=vcm_ref}
N 1240 -250 1240 -220 {lab=vcm_ref}
N 1000 -180 1000 -110 {lab=#net5}
N 1000 -210 1020 -210 {lab=GND}
N 1020 -210 1020 -80 {lab=GND}
N 1000 -80 1020 -80 {lab=GND}
N 1780 -160 1890 -160 {lab=#net6}
N 1670 -390 1670 -280 {lab=#net7}
N 1890 -390 1890 -280 {lab=vctrl}
N 1670 -570 1670 -480 {lab=VDD}
N 1890 -570 1890 -480 {lab=VDD}
N 1930 -250 2010 -250 {lab=vcm_ref}
N 1570 -250 1630 -250 {lab=vout_plus}
N 1710 -480 1850 -480 {lab=#net7}
N 1670 -570 1890 -570 {lab=VDD}
N 1670 -160 1780 -160 {lab=#net6}
N 1670 -250 1890 -250 {lab=GND}
N 1780 -160 1780 -140 {lab=#net6}
N 1890 -450 1890 -390 {lab=vctrl}
N 1670 -450 1670 -390 {lab=#net7}
N 1780 -480 1780 -420 {lab=#net7}
N 1670 -420 1780 -420 {lab=#net7}
N 1480 -340 1480 -280 {lab=#net7}
N 1480 -340 1670 -340 {lab=#net7}
N 1480 -160 1670 -160 {lab=#net6}
N 1400 -250 1440 -250 {lab=vout_minus}
N 1780 -140 1780 -110 {lab=#net6}
N 1780 -50 1780 0 {lab=GND}
N 1780 -80 1780 -50 {lab=GND}
N 1480 -250 1530 -250 {lab=GND}
N 1000 -520 1000 -450 {lab=VDD}
N 1240 -520 1240 -510 {lab=VDD}
N 2650 -260 2690 -260 {lab=VDZ_RP}
N 2650 -260 2650 -200 {lab=VDZ_RP}
N 2650 -200 2730 -200 {lab=VDZ_RP}
N 2730 -230 2730 -200 {lab=VDZ_RP}
N 2730 -290 2730 -260 {lab=VDD}
N 2730 -110 2730 -60 {lab=GND}
N 2730 -200 2730 -170 {lab=VDZ_RP}
N 2730 -300 2730 -290 {lab=VDD}
N 2730 -440 2730 -420 {lab=VDD}
N 2730 -420 2730 -300 {lab=VDD}
N 2400 -80 2400 -40 {lab=GND}
N 2400 -170 2400 -140 {lab=vctrln}
N 2980 -180 2980 -110 {lab=Vout_stg2_rn}
N 2900 -80 2940 -80 {lab=vcm_ref}
N 2900 -210 2900 -80 {lab=vcm_ref}
N 2900 -210 2930 -210 {lab=vcm_ref}
N 2930 -210 2940 -210 {lab=vcm_ref}
N 2980 -290 2980 -240 {lab=#net8}
N 2980 -50 2980 0 {lab=GND}
N 2890 -320 2940 -320 {lab=vctrlp}
N 2980 -350 2980 -320 {lab=#net9}
N 2980 -210 3000 -210 {lab=#net9}
N 3000 -350 3000 -210 {lab=#net9}
N 2980 -350 3000 -350 {lab=#net9}
N 2980 -380 2980 -350 {lab=#net9}
N 3240 -70 3300 -70 {lab=VDZ_RN}
N 3240 -150 3240 -70 {lab=VDZ_RN}
N 3240 -180 3340 -180 {lab=VDZ_RN}
N 3340 -70 3340 -40 {lab=GND}
N 3340 -40 3340 0 {lab=GND}
N 3340 -320 3340 -270 {lab=VDD}
N 3340 -120 3340 -100 {lab=VDZ_RN}
N 3240 -180 3240 -150 {lab=VDZ_RN}
N 3340 -210 3340 -180 {lab=VDZ_RN}
N 3340 -180 3340 -120 {lab=VDZ_RN}
N 3120 -360 3120 -320 {lab=GND}
N 3120 -450 3120 -420 {lab=vctrlp}
N 2980 -80 2980 -50 {lab=GND}
N 2260 -340 2260 -260 {lab=Vout_stg2_rp}
N 2260 -400 2260 -370 {lab=#net10}
N 2160 -370 2220 -370 {lab=vcm_ref}
N 2160 -370 2160 -230 {lab=vcm_ref}
N 2160 -230 2220 -230 {lab=vcm_ref}
N 2260 -200 2260 -130 {lab=#net11}
N 2260 -70 2260 -30 {lab=GND}
N 2260 -100 2260 -70 {lab=GND}
N 2170 -100 2220 -100 {lab=vctrln}
N 2260 -410 2260 -400 {lab=#net10}
N 2730 -60 2730 -10 {lab=GND}
N 2730 -10 2730 0 {lab=GND}
N 2260 -30 2260 0 {lab=GND}
N 2400 -40 2400 0 {lab=GND}
N 3340 -520 3340 -320 {lab=VDD}
N 2730 -520 2730 -440 {lab=VDD}
N 2980 -520 2980 -440 {lab=VDD}
N 2260 -520 2260 -470 {lab=VDD}
N 2260 -230 2280 -230 {lab=GND}
N 2280 -230 2280 -100 {lab=GND}
N 2260 -100 2280 -100 {lab=GND}
N 2260 -520 3340 -520 {lab=VDD}
N 2260 0 3340 -0 {lab=GND}
N 1110 -990 1110 -910 {lab=vgp}
N 1110 -1050 1110 -1020 {lab=#net12}
N 1010 -1020 1070 -1020 {lab=vout_plus}
N 1010 -1020 1010 -880 {lab=vout_plus}
N 1010 -880 1070 -880 {lab=vout_plus}
N 1110 -850 1110 -780 {lab=#net13}
N 1110 -720 1110 -680 {lab=GND}
N 1110 -750 1110 -720 {lab=GND}
N 1020 -750 1070 -750 {lab=vctrln}
N 1110 -1060 1110 -1050 {lab=#net12}
N 1110 -680 1110 -650 {lab=GND}
N 1110 -1170 1110 -1120 {lab=VDD}
N 950 -950 1010 -950 {lab=vout_plus}
N 1460 -830 1460 -760 {lab=vgn}
N 1380 -730 1420 -730 {lab=vout_plus}
N 1380 -860 1380 -730 {lab=vout_plus}
N 1380 -860 1410 -860 {lab=vout_plus}
N 1410 -860 1420 -860 {lab=vout_plus}
N 1460 -940 1460 -890 {lab=#net14}
N 1460 -700 1460 -650 {lab=GND}
N 1370 -970 1420 -970 {lab=vctrlp}
N 1460 -1000 1460 -970 {lab=#net15}
N 1460 -860 1480 -860 {lab=#net15}
N 1480 -1000 1480 -860 {lab=#net15}
N 1460 -1000 1480 -1000 {lab=#net15}
N 1460 -1030 1460 -1000 {lab=#net15}
N 1460 -730 1460 -700 {lab=GND}
N 1460 -1170 1460 -1090 {lab=VDD}
N 1320 -800 1380 -800 {lab=vout_plus}
N 1110 -950 1240 -950 {lab=vgp}
N 1460 -790 1670 -790 {lab=vgn}
N 1110 -880 1130 -880 {lab=GND}
N 1130 -880 1130 -750 {lab=GND}
N 1110 -750 1130 -750 {lab=GND}
N 2200 -760 2200 -680 {lab=#net16}
N 2200 -930 2200 -820 {lab=#net17}
N 2200 -1050 2200 -990 {lab=VDD}
N 2080 -960 2160 -960 {lab=vgp}
N 2200 -990 2200 -960 {lab=VDD}
N 2080 -790 2160 -790 {lab=vgn}
N 2200 -790 2200 -760 {lab=#net16}
N 2340 -880 2340 -860 {lab=Vout}
N 2340 -890 2340 -880 {lab=Vout}
N 2200 -890 2340 -890 {lab=Vout}
N 2340 -800 2340 -700 {lab=GND}
N 2200 -700 2340 -700 {lab=GND}
C {symbols/nfet_03v3.sym} 390 -270 0 0 {name=M1
L=0.3u
W=1u
nf=2
m=2
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 430 -500 0 1 {name=M3
L=0.5u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/vdd.sym} 520 -590 0 0 {name=l2 lab=VDD}
C {devices/gnd.sym} 520 -270 0 0 {name=l7 lab=GND}
C {devices/lab_pin.sym} 520 -500 1 0 {name=p3 sig_type=std_logic lab=vctrl}
C {devices/vsource.sym} 310 -240 0 0 {name=V2 value="dc 1.65 ac 1" savecurrent=false}
C {devices/gnd.sym} 310 -210 0 0 {name=l8 lab=GND}
C {devices/ngspice_probe.sym} 520 -180 0 0 {name=r7}
C {symbols/nfet_03v3.sym} 500 -70 0 0 {name=M8
L=2u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/ngspice_probe.sym} 370 -70 0 0 {name=r8}
C {devices/ammeter.sym} 520 -130 0 0 {name=Vmeas2 savecurrent=true spice_ignore=0}
C {devices/gnd.sym} 520 0 0 0 {name=l1 lab=GND}
C {devices/vsource.sym} 750 -240 0 0 {name=V3 value="dc 1.65 ac 1 180" savecurrent=false}
C {devices/gnd.sym} 750 -210 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} 310 -270 1 0 {name=p6 sig_type=std_logic lab=vin_plus}
C {devices/lab_pin.sym} 750 -270 1 0 {name=p7 sig_type=std_logic lab=vin_minus}
C {devices/lab_pin.sym} 630 -410 2 0 {name=p8 sig_type=std_logic lab=vout_plus}
C {devices/lab_pin.sym} 410 -410 2 1 {name=p9 sig_type=std_logic lab=vout_minus}
C {devices/ngspice_get_value.sym} 660 -230 0 0 {name=r11 node=@m.xm2.m0[gm]
descr="gm2"}
C {devices/ngspice_get_value.sym} 660 -200 0 0 {name=r12 node=@m.xm2.m0[gds]
descr="gds2"}
C {devices/ngspice_get_value.sym} 660 -170 0 0 {name=r14 node=@m.xm2.m0[cgg]
descr="cgg2"}
C {devices/ngspice_get_value.sym} 660 -140 0 0 {name=r15 node=v(@m.xm2.m0[vth])
descr="vth2"}
C {devices/ngspice_get_value.sym} 740 -520 0 0 {name=r20 node=@m.xm4.m0[gm]
descr="gm4"}
C {devices/ngspice_get_value.sym} 740 -490 0 0 {name=r21 node=@m.xm4.m0[gds]
descr="gds4"}
C {devices/ngspice_get_value.sym} 740 -460 0 0 {name=r22 node=@m.xm4.m0[cgg]
descr="cgg4"}
C {devices/ngspice_get_value.sym} 740 -430 0 0 {name=r23 node=v(@m.xm4.m0[vth])
descr="vth4"}
C {devices/lab_pin.sym} 350 -70 3 1 {name=p14 sig_type=std_logic lab=vbias}
C {symbols/nfet_03v3.sym} 150 -70 0 1 {name=M9
L=2u
W=4u
nf=1
m=5
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/isource.sym} 130 -420 0 0 {name=I0 value=10u}
C {symbols/nfet_03v3.sym} 650 -270 0 1 {name=M2
L=0.3u
W=1u
nf=2
m=2
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 610 -500 0 0 {name=M4
L=0.5u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/vsource.sym} 0 -340 0 0 {name=V1 value=3.3 savecurrent=false}
C {devices/gnd.sym} 0 -270 0 0 {name=l5 lab=GND}
C {devices/vdd.sym} 0 -420 0 0 {name=l6 lab=VDD}
C {devices/ngspice_probe.sym} 1000 -140 0 0 {name=r3
}
C {devices/ammeter.sym} 1000 -420 0 0 {name=Vmeas1 savecurrent=true }
C {devices/vdd.sym} 910 -80 0 0 {name=l15 lab=VDD
}
C {devices/ammeter.sym} 1240 -480 0 0 {name=Vmeas3 savecurrent=true }
C {devices/ngspice_probe.sym} 1240 -330 0 1 {name=r4
}
C {devices/gnd.sym} 1150 -390 0 0 {name=l18 lab=GND
}
C {devices/lab_pin.sym} 1110 -280 3 1 {name=p1 sig_type=std_logic lab=vcm_ref
}
C {symbols/pfet_03v3.sym} 980 -350 0 0 {name=M5
L=0.5u
W=0.5u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 980 -210 0 0 {name=M6
L=0.5u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 980 -80 0 0 {name=M11
L=0.28u
W=0.22u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1220 -150 0 0 {name=M13
L=0.5u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1220 -280 0 0 {name=M12
L=0.5u
W=0.5u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1220 -390 0 0 {name=M7
L=0.28u
W=0.22u
nf=1
m=20
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1910 -250 0 1 {name=M18
L=0.5u
W=0.75u
nf=1
m=2
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1690 -480 0 1 {name=M19
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1870 -480 0 0 {name=M20
L=2u
W=2u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/vdd.sym} 1780 -570 0 0 {name=l4 lab=VDD
}
C {devices/gnd.sym} 1780 -250 0 0 {name=l9 lab=GND
}
C {devices/ngspice_probe.sym} 1780 -160 0 0 {name=r27
}
C {devices/ngspice_get_value.sym} 1940 -170 0 0 {name=r28 node=@m.xm18.m0[gm]
descr="gm18"
}
C {devices/ngspice_get_value.sym} 1940 -140 0 0 {name=r29 node=@m.xm18.m0[gds]
descr="gds18"
}
C {devices/ngspice_get_value.sym} 1940 -110 0 0 {name=r30 node=@m.xm18.m0[cgg]
descr="cgg18"
}
C {devices/ngspice_get_value.sym} 1940 -80 0 0 {name=r31 node=v(@m.xm18.m0[vth])
descr="vth18"
}
C {devices/ngspice_get_value.sym} 2000 -500 0 0 {name=r32 node=@m.xm20.m0[gm]
descr="gm20"
}
C {devices/ngspice_get_value.sym} 2000 -470 0 0 {name=r33 node=@m.xm20.m0[gds]
descr="gds20"
}
C {devices/ngspice_get_value.sym} 2000 -440 0 0 {name=r34 node=@m.xm20.m0[cgg]
descr="cgg20"
}
C {devices/ngspice_get_value.sym} 2000 -410 0 0 {name=r35 node=v(@m.xm20.m0[vth])
descr="vth20"
}
C {symbols/nfet_03v3.sym} 1460 -250 0 0 {name=M21
L=0.5u
W=0.75u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/lab_pin.sym} 1740 -80 2 1 {name=p15 sig_type=std_logic lab=vbias
}
C {symbols/nfet_03v3.sym} 1760 -80 0 0 {name=M22
L=2u
W=4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/gnd.sym} 1780 0 0 0 {name=l11 lab=GND
}
C {devices/lab_pin.sym} 1400 -250 3 1 {name=p2 sig_type=std_logic lab=vout_minus
}
C {devices/lab_pin.sym} 1570 -250 1 0 {name=p10 sig_type=std_logic lab=vout_plus
}
C {devices/lab_pin.sym} 1890 -370 2 0 {name=p12 sig_type=std_logic lab=vctrl
}
C {devices/lab_pin.sym} 2010 -250 3 1 {name=p13 sig_type=std_logic lab=vcm_ref
}
C {devices/gnd.sym} 1530 -250 0 0 {name=l10 lab=GND
}
C {devices/vdd.sym} 1120 -520 0 0 {name=l12 lab=VDD
}
C {devices/gnd.sym} 1120 0 0 0 {name=l13 lab=GND
}
C {devices/ngspice_get_value.sym} 1390 -170 0 0 {name=r1 node=@m.xm21.m0[gm]
descr="gm21"}
C {devices/ngspice_get_value.sym} 1390 -140 0 0 {name=r2 node=@m.xm21.m0[gds]
descr="gds21"}
C {devices/ngspice_get_value.sym} 1390 -110 0 0 {name=r5 node=@m.xm21.m0[cgg]
descr="cgg21"}
C {devices/ngspice_get_value.sym} 1390 -80 0 0 {name=r6 node=v(@m.xm21.m0[vth])
descr="vth21"}
C {devices/ngspice_get_value.sym} 1860 -40 0 0 {name=r9 node=@m.xm22.m0[gm]
descr="gm22"}
C {devices/ngspice_get_value.sym} 1860 -10 0 0 {name=r10 node=@m.xm22.m0[gds]
descr="gds22"}
C {devices/ngspice_get_value.sym} 1860 20 0 0 {name=r13 node=@m.xm22.m0[cgg]
descr="cgg22"}
C {devices/ngspice_get_value.sym} 1860 50 0 0 {name=r16 node=v(@m.xm22.m0[vth])
descr="vth22"}
C {devices/ngspice_get_value.sym} 1550 -500 0 0 {name=r17 node=@m.xm19.m0[gm]
descr="gm19"}
C {devices/ngspice_get_value.sym} 1550 -470 0 0 {name=r18 node=@m.xm19.m0[gds]
descr="gds19"}
C {devices/ngspice_get_value.sym} 1550 -440 0 0 {name=r19 node=@m.xm19.m0[cgg]
descr="cgg19"}
C {devices/ngspice_get_value.sym} 1550 -410 0 0 {name=r24 node=v(@m.xm19.m0[vth])
descr="vth19"}
C {devices/ngspice_get_value.sym} 1610 -120 0 0 {name=r25 node=@m.xm17.m0[gm]
descr="gm17"}
C {devices/ngspice_get_value.sym} 1610 -90 0 0 {name=r26 node=@m.xm17.m0[gds]
descr="gds17"}
C {devices/ngspice_get_value.sym} 1610 -60 0 0 {name=r36 node=@m.xm17.m0[cgg]
descr="cgg17"}
C {devices/ngspice_get_value.sym} 1610 -30 0 0 {name=r37 node=v(@m.xm17.m0[vth])
descr="vth17"}
C {symbols/nfet_03v3.sym} 1650 -250 0 0 {name=M17
L=0.5u
W=0.75u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/ammeter.sym} 1480 -190 0 0 {name=Vmeas4 savecurrent=true spice_ignore=0}
C {devices/ammeter.sym} 1670 -190 0 0 {name=Vmeas5 savecurrent=true spice_ignore=0}
C {devices/ammeter.sym} 1890 -190 0 0 {name=Vmeas6 savecurrent=true spice_ignore=0}
C {devices/gnd.sym} 2730 0 0 0 {name=l14 lab=GND}
C {symbols/pfet_03v3.sym} 2710 -260 0 0 {name=M10
L=0.5u
W=15.375u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/isource.sym} 2730 -140 0 0 {name=I2 value=10u}
C {devices/bsource.sym} 2400 -110 0 0 {name=B2 VAR=V FUNC="3.3 / ( 1 + exp(-10000 * V(Vout_stg2_rp,VDZ_RP)))" }
C {devices/lab_pin.sym} 2650 -260 0 0 {name=p4 sig_type=std_logic lab=VDZ_RP}
C {devices/lab_pin.sym} 2400 -170 2 0 {name=p5 sig_type=std_logic lab=vctrln}
C {devices/launcher.sym} 2470 -360 0 0 {name=h2
descr="load op & annotate" 
tclcommand="xschem raw_read $netlist_dir/Inv-Damp.raw; set show_hidden_texts 1; xschem annotate_op"}
C {symbols/pfet_03v3.sym} 2960 -210 0 0 {name=M14
L=0.5u
W=0.5u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2960 -80 0 0 {name=M15
L=0.5u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2960 -320 0 0 {name=M16
L=0.28u
W=0.22u
nf=1
m=20
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {devices/lab_pin.sym} 2890 -320 0 0 {name=p16 sig_type=std_logic lab=vctrlp}
C {devices/ammeter.sym} 2980 -410 0 0 {name=Vmeas7 savecurrent=true spice_ignore=0}
C {symbols/nfet_03v3.sym} 3320 -70 0 0 {name=M23
L=0.5u
W=5u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/isource.sym} 3340 -240 0 0 {name=I1 value=10u}
C {devices/bsource.sym} 3120 -390 0 0 {name=B1 VAR=V FUNC="3.3 / ( 1 + exp(-10000 * V(Vout_stg2_rn,VDZ_RN)))" }
C {devices/gnd.sym} 3120 -320 0 0 {name=l16 lab=GND}
C {devices/lab_pin.sym} 3120 -450 2 0 {name=p17 sig_type=std_logic lab=vctrlp}
C {devices/lab_pin.sym} 3240 -180 0 0 {name=p18 sig_type=std_logic lab=VDZ_RN}
C {devices/lab_pin.sym} 2980 -150 0 1 {name=p19 sig_type=std_logic lab=Vout_stg2_rn}
C {devices/ngspice_probe.sym} 2980 -260 0 1 {name=r38}
C {devices/vdd.sym} 2560 -520 0 0 {name=l17 lab=VDD}
C {symbols/nfet_03v3.sym} 2240 -230 0 0 {name=M24
L=0.5u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 2240 -370 0 0 {name=M25
L=0.5u
W=0.5u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2240 -100 0 0 {name=M26
L=0.28u
W=0.22u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/ngspice_probe.sym} 2260 -160 0 0 {name=r39}
C {devices/ammeter.sym} 2260 -440 0 0 {name=Vmeas8 savecurrent=true spice_ignore=0}
C {devices/lab_pin.sym} 2170 -100 2 1 {name=p20 sig_type=std_logic lab=vctrln}
C {devices/lab_pin.sym} 2260 -300 0 1 {name=p22 sig_type=std_logic lab=Vout_stg2_rp}
C {devices/lab_pin.sym} 2160 -290 0 0 {name=p23 sig_type=std_logic lab=vcm_ref
}
C {devices/lab_pin.sym} 2900 -150 0 0 {name=p11 sig_type=std_logic lab=vcm_ref
}
C {devices/ngspice_probe.sym} 1110 -810 0 0 {name=r40}
C {devices/ammeter.sym} 1110 -1090 0 0 {name=Vmeas9 savecurrent=true spice_ignore=0}
C {devices/lab_pin.sym} 1020 -750 2 1 {name=p21 sig_type=std_logic lab=vctrln}
C {devices/gnd.sym} 1110 -650 0 0 {name=l20 lab=GND}
C {devices/vdd.sym} 1110 -1170 0 0 {name=l21 lab=VDD}
C {devices/lab_pin.sym} 1370 -970 0 0 {name=p25 sig_type=std_logic lab=vctrlp}
C {devices/ammeter.sym} 1460 -1060 0 0 {name=Vmeas10 savecurrent=true spice_ignore=0}
C {devices/ngspice_probe.sym} 1460 -910 0 1 {name=r41}
C {devices/vdd.sym} 1460 -1170 0 0 {name=l22 lab=VDD}
C {devices/gnd.sym} 1460 -650 0 0 {name=l23 lab=GND}
C {devices/lab_pin.sym} 1240 -950 3 1 {name=p27 sig_type=std_logic lab=vgp}
C {devices/lab_pin.sym} 1670 -790 3 1 {name=p28 sig_type=std_logic lab=vgn}
C {symbols/pfet_03v3.sym} 1090 -1020 0 0 {name=M27
L=0.5u
W=0.5u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1090 -880 0 0 {name=M28
L=0.5u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1090 -750 0 0 {name=M29
L=0.28u
W=0.22u
nf=1
m=6
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1440 -970 0 0 {name=M30
L=0.28u
W=0.22u
nf=1
m=20
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 1440 -860 0 0 {name=M31
L=0.5u
W=0.5u
nf=1
m=3
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 1440 -730 0 0 {name=M32
L=0.5u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/lab_pin.sym} 950 -950 2 1 {name=p24 sig_type=std_logic lab=vout_plus}
C {devices/lab_pin.sym} 1320 -800 2 1 {name=p26 sig_type=std_logic lab=vout_plus}
C {symbols/pfet_03v3.sym} 2180 -960 0 0 {name=M33
L=0.5u
W=15.375u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 2180 -790 0 0 {name=M34
L=0.5u
W=5u
nf=1
m=8
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {devices/lab_pin.sym} 2080 -960 2 1 {name=p29 sig_type=std_logic lab=vgp}
C {devices/lab_pin.sym} 2080 -790 2 1 {name=p30 sig_type=std_logic lab=vgn}
C {devices/vdd.sym} 2200 -1050 0 0 {name=l19 lab=VDD}
C {devices/gnd.sym} 2200 -680 0 0 {name=l24 lab=GND}
C {devices/capa.sym} 2340 -830 0 0 {name=C1
m=1
value=250p
footprint=1206
device="ceramic capacitor"}
C {devices/lab_pin.sym} 2340 -890 0 1 {name=p31 sig_type=std_logic lab=Vout}
C {devices/code_shown.sym} 130 -1230 0 0 {name=NGSPICE only_toplevel=true 
value="
.option wnflag=1
.option savecurrents
.temp 27
.control
save all
write RAMP_test_try_05u.raw
set appendwrite 
op
write RAMP_test_try_05u.raw
**dc V1 0 1.65 1m
**tran 1m 10m 1m
**tran 100n 5u 100n
ac dec 20 1 1e10
plot vdb(vout)
.endc
"}
C {devices/code.sym} 140 -820 0 0 {name=SAVE_COMMANDS only_toplevel=false value="
.save @m.xm1.m0[gm]
.save @m.xm1.m0[id]
.save @m.xm1.m0[vth]
.save @m.xm1.m0[vds]
.save @m.xm1.m0[gds]
.save @m.xm1.m0[cgg]
.save @m.xm1.m0[cgs]
.save @m.xm1.m0[cgd]
.save @m.xm2.m0[gm]
.save @m.xm2.m0[id]
.save @m.xm2.m0[vth]
.save @m.xm2.m0[vds]
.save @m.xm2.m0[gds]
.save @m.xm2.m0[cgg]
.save @m.xm2.m0[cgs]
.save @m.xm2.m0[cgd]
.save @m.xm3.m0[gm]
.save @m.xm3.m0[id]
.save @m.xm3.m0[vth]
.save @m.xm3.m0[vds]
.save @m.xm3.m0[gds]
.save @m.xm3.m0[cgg]
.save @m.xm3.m0[cgs]
.save @m.xm3.m0[cgd]
.save @m.xm4.m0[gm]
.save @m.xm4.m0[id]
.save @m.xm4.m0[vth]
.save @m.xm4.m0[vds]
.save @m.xm4.m0[gds]
.save @m.xm4.m0[cgg]
.save @m.xm4.m0[cgs]
.save @m.xm4.m0[cgd]
.save @m.xm5.m0[gm]
.save @m.xm5.m0[id]
.save @m.xm5.m0[vth]
.save @m.xm5.m0[vds]
.save @m.xm5.m0[gds]
.save @m.xm5.m0[cgg]
.save @m.xm5.m0[cgs]
.save @m.xm5.m0[cgd]
.save @m.xm6.m0[gm]
.save @m.xm6.m0[id]
.save @m.xm6.m0[vth]
.save @m.xm6.m0[vds]
.save @m.xm6.m0[gds]
.save @m.xm6.m0[cgg]
.save @m.xm6.m0[cgs]
.save @m.xm6.m0[cgd]
.save @m.xm7.m0[gm]
.save @m.xm7.m0[id]
.save @m.xm7.m0[vth]
.save @m.xm7.m0[vds]
.save @m.xm7.m0[gds]
.save @m.xm7.m0[cgg]
.save @m.xm7.m0[cgs]
.save @m.xm7.m0[cgd]
.save @m.xm8.m0[gm]
.save @m.xm8.m0[id]
.save @m.xm8.m0[vth]
.save @m.xm8.m0[vds]
.save @m.xm8.m0[gds]
.save @m.xm8.m0[cgg]
.save @m.xm8.m0[cgs]
.save @m.xm8.m0[cgd]
.save @m.xm9.m0[gm]
.save @m.xm9.m0[id]
.save @m.xm9.m0[vth]
.save @m.xm9.m0[vds]
.save @m.xm9.m0[gds]
.save @m.xm9.m0[cgg]
.save @m.xm9.m0[cgs]
.save @m.xm9.m0[cgd]
.save @m.xm10.m0[gm]
.save @m.xm10.m0[id]
.save @m.xm10.m0[vth]
.save @m.xm10.m0[vds]
.save @m.xm10.m0[gds]
.save @m.xm10.m0[cgg]
.save @m.xm10.m0[cgs]
.save @m.xm10.m0[cgd]
.save @m.xm11.m0[gm]
.save @m.xm11.m0[id]
.save @m.xm11.m0[vth]
.save @m.xm11.m0[vds]
.save @m.xm11.m0[gds]
.save @m.xm11.m0[cgg]
.save @m.xm11.m0[cgs]
.save @m.xm11.m0[cgd]
.save @m.xm12.m0[gm]
.save @m.xm12.m0[id]
.save @m.xm12.m0[vth]
.save @m.xm12.m0[vds]
.save @m.xm12.m0[gds]
.save @m.xm12.m0[cgg]
.save @m.xm12.m0[cgs]
.save @m.xm12.m0[cgd]
.save @m.xm13.m0[gm]
.save @m.xm13.m0[id]
.save @m.xm13.m0[vth]
.save @m.xm13.m0[vds]
.save @m.xm13.m0[gds]
.save @m.xm13.m0[cgg]
.save @m.xm13.m0[cgs]
.save @m.xm13.m0[cgd]
.save @m.xm14.m0[gm]
.save @m.xm14.m0[id]
.save @m.xm14.m0[vth]
.save @m.xm14.m0[vds]
.save @m.xm14.m0[gds]
.save @m.xm14.m0[cgg]
.save @m.xm14.m0[cgs]
.save @m.xm14.m0[cgd]
.save @m.xm15.m0[gm]
.save @m.xm15.m0[id]
.save @m.xm15.m0[vth]
.save @m.xm15.m0[vds]
.save @m.xm15.m0[gds]
.save @m.xm15.m0[cgg]
.save @m.xm15.m0[cgs]
.save @m.xm15.m0[cgd]
.save @m.xm16.m0[gm]
.save @m.xm16.m0[id]
.save @m.xm16.m0[vth]
.save @m.xm16.m0[vds]
.save @m.xm16.m0[gds]
.save @m.xm16.m0[cgg]
.save @m.xm16.m0[cgs]
.save @m.xm16.m0[cgd]
.save @m.xm17.m0[gm]
.save @m.xm17.m0[id]
.save @m.xm17.m0[vth]
.save @m.xm17.m0[vds]
.save @m.xm17.m0[gds]
.save @m.xm17.m0[cgg]
.save @m.xm17.m0[cgs]
.save @m.xm17.m0[cgd]
.save @m.xm18.m0[gm]
.save @m.xm18.m0[id]
.save @m.xm18.m0[vth]
.save @m.xm18.m0[vds]
.save @m.xm18.m0[gds]
.save @m.xm18.m0[cgg]
.save @m.xm18.m0[cgs]
.save @m.xm18.m0[cgd]
.save @m.xm19.m0[gm]
.save @m.xm19.m0[id]
.save @m.xm19.m0[vth]
.save @m.xm19.m0[vds]
.save @m.xm19.m0[gds]
.save @m.xm19.m0[cgg]
.save @m.xm19.m0[cgs]
.save @m.xm19.m0[cgd]
.save @m.xm20.m0[gm]
.save @m.xm20.m0[id]
.save @m.xm20.m0[vth]
.save @m.xm20.m0[vds]
.save @m.xm20.m0[gds]
.save @m.xm20.m0[cgg]
.save @m.xm20.m0[cgs]
.save @m.xm20.m0[cgd]
.save @m.xm21.m0[gm]
.save @m.xm21.m0[id]
.save @m.xm21.m0[vth]
.save @m.xm21.m0[vds]
.save @m.xm21.m0[gds]
.save @m.xm21.m0[cgg]
.save @m.xm21.m0[cgs]
.save @m.xm21.m0[cgd]
.save @m.xm22.m0[gm]
.save @m.xm22.m0[id]
.save @m.xm22.m0[vth]
.save @m.xm22.m0[vds]
.save @m.xm22.m0[gds]
.save @m.xm22.m0[cgg]
.save @m.xm22.m0[cgs]
.save @m.xm22.m0[cgd]
"}
C {devices/launcher.sym} 220 -880 0 0 {name=h1
descr="load op & annotate" 
tclcommand="xschem raw_read $netlist_dir/Inv-Damp.raw; set show_hidden_texts 1; xschem annotate_op"}
C {devices/code.sym} 290 -820 0 0 {name=MODELS only_toplevel=true
format="tcleval( @value )"
value="
.lib /foss/pdks/volare/gf180mcu/versions/0fe599b2afb6708d281543108caf8310912f54af/gf180mcuD/libs.tech/ngspice/sm141064.ngspice typical
.include /foss/pdks/volare/gf180mcu/versions/0fe599b2afb6708d281543108caf8310912f54af/gf180mcuD/libs.tech/ngspice/design.ngspice 
.lib /foss/pdks/volare/gf180mcu/versions/0fe599b2afb6708d281543108caf8310912f54af/gf180mcuD/libs.tech/ngspice/sm141064.ngspice res_statistical

**.include $::180MCU_MODELS/design.ngspice
**.lib $::180MCU_MODELS/sm141064.ngspice typical
**.lib $::180MCU_MODELS/sm141064.ngspice res_typical
* .lib $::180MCU_MODELS/sm141064.ngspice res_statistical
*.include $::180MCU_MODELS/design.ngspice
*.lib $::180MCU_MODELS/sm141064.ngspice typical

"}
